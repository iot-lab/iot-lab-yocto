# GCC 6.3 invalid option
CFLAGS_remove = "-Wno-error=stringop-overflow"
