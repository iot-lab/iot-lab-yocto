include iotlab-image.inc

# Include modules in rootfs
IMAGE_INSTALL += " \
		kernel-modules \
		linux-node-packagegroup \
		"
