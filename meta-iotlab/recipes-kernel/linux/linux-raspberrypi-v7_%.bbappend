FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://binfmt-elf.cfg"
