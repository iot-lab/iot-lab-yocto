CFLAG_append_class-native = " -fPIC"

