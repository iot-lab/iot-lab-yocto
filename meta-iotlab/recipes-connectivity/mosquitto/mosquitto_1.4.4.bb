require mosquitto.inc

DEPENDS += " libwebsockets"
RDEPENDS_${PN} += " libwebsockets"

SRC_URI[md5sum] = "89a57f11cdfec140fa21fe3d4493b2ca"
SRC_URI[sha256sum] = "c643c7123708aadcd29287dda7b5ce7c910f75b02956a8fc4fe65ad2ea767a5f"
