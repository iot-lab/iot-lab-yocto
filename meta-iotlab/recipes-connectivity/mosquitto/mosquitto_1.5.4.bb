require mosquitto.inc

SRC_URI[md5sum] = "4fe8eb707777eb4bfcb5cd432c30a467"
SRC_URI[sha256sum] = "5fd7f3454fd6d286645d032bc07f44a1c8583cec02ef2422c9eb32e0a89a9b2f"
