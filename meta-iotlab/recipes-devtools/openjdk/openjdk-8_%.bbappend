FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
PATCHES_URI_append += "file://openjdk8-enable-hotSpot-builds-on-5.x-linux-kernels.patch;apply=no"

