## -*-conf-*-
DESCRIPTION = "Atomic file writes."
HOMEPAGE = "https://pypi.python.org/pypi/atomicwrites"
SECTION = "devel/python"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=91cc36cfafeefb7863673bcfcb1d4da4"

PR = "r0"

SRC_URI[md5sum] = "2669c1222f2886cab9a1f1d6370d47da"
SRC_URI[sha256sum] = "240831ea22da9ab882b551b31d4225591e5e447a68c5e188db5b89ca1d487585"

inherit pypi setuptools
