## -*-conf-*-
DESCRIPTION = "Fast and simple WSGI-framework for small web-applications"
HOMEPAGE = "https://pypi.python.org/pypi/bottle/"
SECTION = "devel/python"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://README.rst;md5=1f9017c97709920b7382f39fb402466f"

SRC_URI[md5sum] = "a00b7e9a1ab3be7c19c1235fea2ccb40"
SRC_URI[sha256sum] = "0819b74b145a7def225c0e83b16a4d5711fde751cd92bae467a69efce720f69e"

PYPI_PACKAGE = "bottle"

inherit pypi setuptools3
