SUMMARY = "Tools for using a Web Server Gateway Interface stack"
HOMEPAGE = "http://pythonpaste.org/"
LICENSE = "MIT"

LIC_FILES_CHKSUM = "file://docs/license.txt;md5=1798f29d55080c60365e6283cb49779c"

SRC_URI[md5sum] = "1e60b2fbaf60da2d670468d9863427cb"
SRC_URI[sha256sum] = "379c50d0a8016cc15b15d7f43445d8b9ac4b662943a0f6dcb8b08095deb158b3"

PYPI_PACKAGE = "Paste"
inherit pypi setuptools3
