## -*-conf-*-
DESCRIPTION = "More routines for operating on iterables, beyond itertools"
HOMEPAGE = "https://pypi.python.org/pypi/more-itertools"
SECTION = "devel/python"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=3396ea30f9d21389d7857719816f83b5"

PR = "r0"

SRC_URI[md5sum] = "5629c955d17df328ec534989f0649369"
SRC_URI[sha256sum] = "2b6b9893337bfd9166bee6a62c2b0c9fe7735dcf85948b387ec8cba30e85d8e8"

inherit pypi setuptools3
