DESCRIPTION = "A collection of helpers and mock objects for unit tests and doc tests."
SECTION = "devel/python"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://docs/license.txt;md5=b19f00294e65148c2779131bd7a10fd3"

PYPI_PACKAGE = "testfixtures"

SRC_URI[md5sum] = "d988e611192cb633d6a4dfe94af55dd7"
SRC_URI[sha256sum] = "58d2b3146d93bc5ddb0cd24e0ccacb13e29bdb61e5c81235c58f7b8ee4470366"

inherit pypi setuptools3
