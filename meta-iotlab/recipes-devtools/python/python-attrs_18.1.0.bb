## -*-conf-*-
DESCRIPTION = "Classes Without Boilerplate"
HOMEPAGE = "https://pypi.python.org/pypi/attrs"
SECTION = "devel/python"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=d4ab25949a73fe7d4fdee93bcbdbf8ff"

PR = "r0"

SRC_URI[md5sum] = "3f3f3e0750dab74cfa1dc8b0fd7a5f86"
SRC_URI[sha256sum] = "e0d0eb91441a3b53dab4d9b743eafc1ac44476296a2053b6ca3af0b139faf87b"

inherit pypi setuptools
