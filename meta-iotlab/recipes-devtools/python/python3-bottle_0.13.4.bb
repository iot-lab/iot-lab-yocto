## -*-conf-*-
DESCRIPTION = "Fast and simple WSGI-framework for small web-applications"
HOMEPAGE = "https://pypi.python.org/pypi/bottle/"
SECTION = "devel/python"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=8740fee0ffaa1364bffd091f9d316bbf"

SRC_URI[md5sum] = "a8dd2700b477b86a38510a2a31d07c78"
SRC_URI[sha256sum] = "787e78327e12b227938de02248333d788cfe45987edca735f8f88e03472c3f47"

PYPI_PACKAGE = "bottle"

inherit pypi setuptools3
