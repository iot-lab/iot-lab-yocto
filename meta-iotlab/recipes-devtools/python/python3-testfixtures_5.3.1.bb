DESCRIPTION = "A collection of helpers and mock objects for unit tests and doc tests."
SECTION = "devel/python"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://docs/license.txt;md5=b19f00294e65148c2779131bd7a10fd3"

PYPI_PACKAGE = "testfixtures"

SRC_URI[md5sum] = "5d553ddde37b55d43bb904e8c67d9f00"
SRC_URI[sha256sum] = "670ade9410b7132278209e6a2e893caf098b040c4ba4d5ea848367a9c5588728"

inherit pypi setuptools3
