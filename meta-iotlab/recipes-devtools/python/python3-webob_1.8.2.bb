## -*-conf-*-
DESCRIPTION = "WSGI request and response object"
HOMEPAGE = "https://pypi.python.org/pypi/WebOb/"
SECTION = "devel/python"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/MIT;md5=0835ade698e0bcf8506ecda2f7b4f302"

PR = "r0"

PYPI_PACKAGE = "WebOb"

SRC_URI[md5sum] = "d04756e6683fedddba52eafbe9adf404"
SRC_URI[sha256sum] = "1fe722f2ab857685fc96edec567dc40b1875b21219b3b348e58cd8c4d5ea7df3"

inherit pypi setuptools3
