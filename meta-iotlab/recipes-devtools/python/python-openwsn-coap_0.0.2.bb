SUMMARY  = "A CoAP Python library"
HOMEPAGE = "http://www.openwsn.org/"

LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://COPYING.txt;md5=f63ab783bad130c6c58fd85aaff64761"

SRC_URI[md5sum] = "279859d8e0935f9b8eb5454bdb75dbcc"
SRC_URI[sha256sum] = "1e0df2a8c8135e11693a9acacd50c9f33c4a7116768641bc68669a147aabed29"

PYPI_PACKAGE_EXT = "zip"
inherit pypi setuptools
