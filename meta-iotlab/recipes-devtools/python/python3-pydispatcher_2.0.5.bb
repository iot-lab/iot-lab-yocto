DESCRIPTION = "Multi-producer-multi-consumer signal dispatching mechanism"
SECTION = "devel/python"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://license.txt;md5=09dffabd4d29ee02f66b0b7f808d57c2"

PYPI_PACKAGE = "PyDispatcher"

SRC_URI[md5sum] = "1b9c2ca33580c2770577add7130b0b28"
SRC_URI[sha256sum] = "5570069e1b1769af1fe481de6dd1d3a388492acddd2cdad7a3bde145615d5caf"

inherit pypi setuptools3
